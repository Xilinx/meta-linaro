require recipes-kernel/perf/perf_3.4.bb

require linux-libc-headers.inc

PR = "r0"

SRC_URI = "git://git.kernel.org/pub/scm/linux/kernel/git/cmarinas/linux-aarch64.git"

SRCREV = "78e642ac127185b5d1b0d0c7ec134ea8418f85a7"

S = "${WORKDIR}/git"

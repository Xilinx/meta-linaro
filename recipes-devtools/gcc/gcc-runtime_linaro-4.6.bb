require recipes-devtools/gcc/gcc-runtime_4.6.bb

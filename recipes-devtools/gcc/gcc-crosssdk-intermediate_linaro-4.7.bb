require gcc-linaro-common-4.7.inc
require recipes-devtools/gcc/gcc-crosssdk-intermediate_${BASEPV}.bb

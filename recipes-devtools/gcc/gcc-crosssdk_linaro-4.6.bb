require recipes-devtools/gcc/gcc-crosssdk_4.6.bb

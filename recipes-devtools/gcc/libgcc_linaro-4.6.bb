require recipes-devtools/gcc/libgcc_4.6.bb

require recipes-devtools/gcc/gcc-cross_4.6.bb

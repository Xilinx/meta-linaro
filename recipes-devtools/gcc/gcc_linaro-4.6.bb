require recipes-devtools/gcc/gcc_4.6.bb


require recipes-devtools/gcc/gcc-cross-initial_4.6.bb

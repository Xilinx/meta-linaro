require recipes-devtools/gcc/gcc-crosssdk-intermediate_4.6.bb

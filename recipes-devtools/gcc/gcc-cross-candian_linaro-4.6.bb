# Copyright (C) 2012 Khem Raj <khem@openembedded.org>
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-devtools/gcc/gcc-cross-canadian_4.6.bb

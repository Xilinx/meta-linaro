require recipes-devtools/gcc/gcc-cross-intermediate_4.6.bb

require recipes-devtools/gcc/gcc-crosssdk-initial_4.6.bb

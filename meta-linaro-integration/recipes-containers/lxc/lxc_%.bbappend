CFLAGS_append = " -Wno-error=deprecated-declarations"

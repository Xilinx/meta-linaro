PNBLACKLIST[cunit] = ""

inherit remove-libtool

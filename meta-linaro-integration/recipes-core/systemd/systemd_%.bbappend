PACKAGECONFIG_append = " networkd"

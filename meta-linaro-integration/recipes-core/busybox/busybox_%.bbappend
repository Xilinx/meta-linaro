FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://linaro.cfg \
            file://0002-Revert-Passthrough-r-to-linker.patch "

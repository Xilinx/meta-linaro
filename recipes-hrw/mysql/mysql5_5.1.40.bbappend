PRINC = "1"

INITSCRIPT_PARAMS = "start 45 5 . stop 45 0 6 1 ."

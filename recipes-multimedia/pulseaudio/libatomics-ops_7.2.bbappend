FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
          file://0001-libatomic_ops-Aarch64-basic-port.patch \
"

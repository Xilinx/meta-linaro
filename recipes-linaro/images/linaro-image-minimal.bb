require recipes-core/images/core-image-minimal.bb

IMAGE_FEATURES += "ssh-server-openssh"

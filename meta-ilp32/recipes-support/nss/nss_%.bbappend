do_compile_prepend() {
export NSS_ENABLE_WERROR=0
}

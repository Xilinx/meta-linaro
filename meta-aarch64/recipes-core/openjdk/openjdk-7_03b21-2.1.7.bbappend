FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#SRC_URI_append = " file://andy1.diff" 

WITH_ADDITIONAL_VMS_aarch64 = ""

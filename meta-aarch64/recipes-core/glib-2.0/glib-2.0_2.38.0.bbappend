FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0001-gio-Fix-Werror-format-string-errors-from-mismatched-.patch" 

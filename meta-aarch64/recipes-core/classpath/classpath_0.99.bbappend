FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://ieeefp-aarch64.patch" 


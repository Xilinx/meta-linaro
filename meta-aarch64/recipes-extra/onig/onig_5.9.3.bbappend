FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://do-not-use-system-headers.patch"

EXTRA_OEMAKE_aarch64 = "CFLAGS=-O0 'GEN_LEX_HASH=${STAGING_BINDIR_NATIVE}/gen_lex_hash'"

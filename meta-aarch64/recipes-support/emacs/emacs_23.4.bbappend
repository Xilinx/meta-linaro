COMPATIBLE_HOST_aarch64 = "0"

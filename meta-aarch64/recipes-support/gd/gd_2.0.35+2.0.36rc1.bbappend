SRC_URI = "http://people.linaro.org/~hrw/sources/gd-2.0.36RC1.tar.gz"

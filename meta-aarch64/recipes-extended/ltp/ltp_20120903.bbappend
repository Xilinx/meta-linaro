FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://ltp-arm64.patch" 

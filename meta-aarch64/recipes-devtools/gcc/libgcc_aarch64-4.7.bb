require recipes-devtools/gcc/gcc-${PV}.inc
require recipes-devtools/gcc/libgcc_4.7.bb

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

INC_PR = "1"

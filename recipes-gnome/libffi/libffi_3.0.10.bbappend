COMPATIBLE_MACHINE_aarch64 = "fwefw"

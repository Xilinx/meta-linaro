FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://arm-Fix-endianness-in-crashdump-header.patch"

FILESEXTRAPATHS := "${THISDIR}/${PN}"

SRC_URI += "file://aarch64_be-build.patch"

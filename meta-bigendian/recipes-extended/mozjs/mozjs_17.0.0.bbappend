FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-support-for-big-endian-32bit-ARM.patch;patchdir=../../ "

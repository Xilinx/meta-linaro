COMPATIBLE_HOST_aarch64 = "(i.86|x86_64).*-linux"

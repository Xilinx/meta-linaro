FILESEXTRAPATHS_prepend := "${THISDIR}/gmp-5.1.0:"

SRC_URI_append = "file://187b7b1646ee.patch"

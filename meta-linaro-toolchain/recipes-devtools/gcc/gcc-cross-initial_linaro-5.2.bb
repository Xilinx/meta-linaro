BASEPV = "5.2"
PV = "linaro-${BASEPV}"
require recipes-devtools/gcc/gcc-cross-initial_${BASEPV}.bb

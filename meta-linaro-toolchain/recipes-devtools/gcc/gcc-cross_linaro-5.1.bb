BASEPV = "5.1"
PV = "linaro-${BASEPV}"
require recipes-devtools/gcc/gcc-cross_${BASEPV}.bb

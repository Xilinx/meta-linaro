BASEPV = "4.7"
PV = "linaro-${BASEPV}"
require recipes-devtools/gcc/gcc-cross_${BASEPV}.bb

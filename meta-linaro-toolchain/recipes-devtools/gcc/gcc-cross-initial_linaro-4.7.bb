BASEPV = "4.7"
PV = "linaro-${BASEPV}"
require recipes-devtools/gcc/gcc-cross-initial_${BASEPV}.bb

BASEPV = "5.1"
PV = "linaro-${BASEPV}"
require recipes-devtools/gcc/gcc-cross-initial_${BASEPV}.bb

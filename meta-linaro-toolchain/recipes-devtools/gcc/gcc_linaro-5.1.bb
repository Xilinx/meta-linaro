require gcc-linaro-common-5.1.inc
require recipes-devtools/gcc/gcc_${BASEPV}.bb

DEPENDS += "gmp-native"

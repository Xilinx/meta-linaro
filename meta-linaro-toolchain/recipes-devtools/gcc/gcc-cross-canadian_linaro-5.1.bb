require gcc-linaro-common-5.1.inc
require recipes-devtools/gcc/gcc-cross-canadian_${BASEPV}.bb

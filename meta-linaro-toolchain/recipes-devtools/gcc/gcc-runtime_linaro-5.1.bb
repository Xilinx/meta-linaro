require gcc-linaro-common-5.1.inc
require recipes-devtools/gcc/gcc-runtime_${BASEPV}.bb

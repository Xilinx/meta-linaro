require gcc-linaro-common-5.1.inc
require gcc-linaro-5.1.inc
require recipes-devtools/gcc/libgfortran.inc


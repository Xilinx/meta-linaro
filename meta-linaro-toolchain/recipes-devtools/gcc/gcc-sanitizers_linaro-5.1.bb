require gcc-linaro-common-5.1.inc
require recipes-devtools/gcc/gcc-${PV}.inc
require recipes-devtools/gcc/gcc-sanitizers.inc

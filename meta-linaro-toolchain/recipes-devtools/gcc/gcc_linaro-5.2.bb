require gcc-linaro-common-5.2.inc
require recipes-devtools/gcc/gcc_${BASEPV}.bb

DEPENDS += "gmp-native"

require gcc-linaro-common-5.2.inc
require recipes-devtools/gcc/gcc-crosssdk_${BASEPV}.bb

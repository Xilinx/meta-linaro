require gcc-linaro-common-5.1.inc
require recipes-devtools/gcc/libgcc_${BASEPV}.bb

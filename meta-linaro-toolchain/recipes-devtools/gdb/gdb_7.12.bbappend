FILESEXTRAPATHS_prepend := "${THISDIR}/gdb:"

SRC_URI += "file://cb93dc7f262978bafe36397a41a56e409a302042.patch"



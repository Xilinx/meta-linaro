require recipes-core/glibc/glibc-scripts.inc
require recipes-core/glibc/glibc_linaro.inc

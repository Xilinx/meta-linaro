require recipes-core/glibc/glibc-locale.inc
require recipes-core/glibc/glibc_linaro.inc

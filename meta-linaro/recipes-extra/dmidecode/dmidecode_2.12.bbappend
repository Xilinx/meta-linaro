COMPATIBLE_HOST = "(i.86|x86_64|aarch64|arm).*-linux"

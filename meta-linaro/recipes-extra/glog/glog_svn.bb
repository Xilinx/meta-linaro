require glog.inc

SRC_URI = "svn://google-glog.googlecode.com/svn/;module=trunk;protocol=http"

SRCREV = "${AUTOREV}"

PV = "0.3.3+svn${SRCPV}"

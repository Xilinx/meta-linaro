LIC_FILES_CHKSUM = "file://COPYING;md5=2c7f2caf277a3933e3acdf7f89d54cc1"
PRDATE = "20130314"
PR = "r${PRDATE}"

SRC_URI[md5sum] = "ed4af7ccfa122f16cf9920b241633a3a"
SRC_URI[sha256sum] = "32fd5979971b772caa96d40646cee585ed0070516ba2dbbcb1f9b6033d08a92d"

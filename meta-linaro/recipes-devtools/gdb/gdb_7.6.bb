require recipes-devtools/gdb/gdb.inc
require gdb-7.6.inc

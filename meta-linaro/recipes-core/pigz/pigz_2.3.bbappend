DEPENDS_class-native = "zlib-native"


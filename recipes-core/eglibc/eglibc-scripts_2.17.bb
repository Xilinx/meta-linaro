require recipes-core/eglibc/eglibc-scripts.inc

RDEPENDS_${PN} = "\
    gdb \
    gdbserver \
    tcf-agent \
    openssh-sftp-server \
    rsync \
    ${MTRACE} \
    "

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
file://aarch64.diff \
"

PRINC = "1"
